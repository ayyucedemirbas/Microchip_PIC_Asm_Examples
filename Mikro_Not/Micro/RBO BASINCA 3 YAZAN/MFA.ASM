LIST P=16F877A
#INCLUDE <P16F877A.INC>
__CONFIG H'3F31'
ORG 0X000
GOTO ANA
ORG 0X004
KESME
BTFSS INTCON,1
RETFIE
BCF INTCON,1
BTFSS PORTD,0
GOTO YAK
CLRF PORTD
RETFIE
YAK
MOVLW H'8F'
MOVWF PORTD
RETFIE
ANA
BSF STATUS,RP0
BSF OPTION_REG,7
BSF TRISB,0
CLRF TRISD
MOVLW B'10010000'
MOVWF INTCON
BCF STATUS,RP0
CLRF PORTD
CLRF PORTB
DONGU
GOTO DONGU 
END