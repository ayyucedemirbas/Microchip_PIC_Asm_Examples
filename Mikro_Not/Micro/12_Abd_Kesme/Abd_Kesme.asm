LIST P=16F877
INCLUDE <P16F877.INC>
SAYAC0 EQU 21H
SAYAC1 EQU 22H
SAYAC2 EQU 23H
SAYAC3 EQU 24H
ORG 0 
GOTO ANA
ORG 4
GOTO KESME

ANA
	BANKSEL TRISD
	CLRF TRISD
	MOVLW H'FF'
	MOVWF TRISB
	BANKSEL PORTB
	CLRF PORTB

	MOVLW b'00001111'
	movwf PORTD	
	
	BANKSEL INTCON
	MOVLW B'11010000'
	MOVWF INTCON
	GOTO $
KESME
	BANKSEL INTCON
	BCF INTCON,1
	BANKSEL PORTD
	SWAPF PORTD,F
	MOVLW D'15'
	CALL GECIK
	RETFIE

GECIK
	MOVWF SAYAC0
DONGU0
	MOVLW D'256'
	MOVWF SAYAC1
DONGU1
	CLRF SAYAC2
DONGU2
	INCFSZ SAYAC2,F
	GOTO DONGU2
	DECFSZ SAYAC1,F
	GOTO DONGU1
	DECFSZ SAYAC0,F
	GOTO DONGU0
	RETURN
END
