list p=16f877a
include "p16f877a.inc"

SAYAC EQU 0x22
SAYAC1 EQU 0x23

ORG 0
GOTO ANA
 ORG 4 
 KESME
BTFSS INTCON,2
RETFIE
BCF INTCON,2
DECFSZ SAYAC1,F
RETFIE
BANKSEL TMR0
MOVLW D'6'
MOVWF TMR0
MOVLW H'FF'
MOVWF SAYAC1
INCF SAYAC,F
MOVF SAYAC,W
MOVWF PORTC
XORLW D'10'
BTFSS STATUS,2
RETFIE
CLRF SAYAC
RETFIE















ANA
BANKSEL TRISC 
CLRF TRISC
 BANKSEL PORTC 
CLRF PORTC
BANKSEL SAYAC
CLRF SAYAC
BANKSEL INTCON
 MOVLW B'10100000'
MOVWF INTCON
BANKSEL OPTION_REG
MOVLW H'0F'
MOVWF OPTION_REG
BANKSEL TMR0
MOVLW D'6'
MOVWF TMR0
BANKSEL SAYAC1
MOVLW h'ff'
MOVWF SAYAC1
DONGU 
GOTO DONGU 
END
