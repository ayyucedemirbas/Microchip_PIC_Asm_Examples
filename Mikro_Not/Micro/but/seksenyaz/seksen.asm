list p=16f877a
include "p16f877a.inc"
org 0
goto ANA
org 4
 KESME 
RETFIE
TABLO 
ADDWF PCL,F
RETLW  H'3F'
RETLW H'7F'
 ANA
 BANKSEL TRISA 
CLRF TRISA
BANKSEL PORTA
CLRF PORTA
MOVLW H'03'
MOVWF PORTA
BANKSEL TRISD 
CLRF TRISD
BANKSEL PORTD
CLRF PORTD
DONGU 
BANKSEL PORTA
MOVLW H'01'
MOVWF PORTA
MOVLW D'0'
CALL TABLO
MOVWF PORTD
MOVWF PORTD
CLRF PORTD
BANKSEL PORTA
MOVLW H'02'
MOVWF PORTA
MOVLW D'1'
CALL TABLO
MOVWF PORTD
MOVWF PORTD
CLRF PORTD

GOTO DONGU
END