list p=16f877a
include "p16f877a.inc"
SAYAC EQU 0x23
org 0
goto ana
org 4
 kesme
BTFSS INTCON,2
RETFIE
BCF INTCON,2
BANKSEL TMR0
MOVLW D'6'
MOVWF TMR0
DECFSZ SAYAC,F
RETFIE
RLF PORTB,F
BANKSEL SAYAC 
MOVLW D'100'
MOVWF SAYAC 
RETFIE

ana 
BANKSEL TRISB 
CLRF TRISB
BANKSEL PORTB
 CLRF PORTB
MOVLW H'01'
MOVWF PORTB
BANKSEL INTCON
MOVLW B'10100000'
MOVWF INTCON
BANKSEL OPTION_REG
MOVLW B'00000100'
MOVWF OPTION_REG
BANKSEL SAYAC
 MOVLW D'100'
MOVWF SAYAC
BANKSEL TMR0
MOVLW D'6'
MOVWF TMR0
DONGU 
GOTO DONGU 
END