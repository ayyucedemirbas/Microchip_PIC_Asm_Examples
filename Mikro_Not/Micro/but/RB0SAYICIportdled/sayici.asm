list p=16f877a
include "p16f877a.inc"
SAYAC EQU 0x23
ORG 0
goto ANA
ORG 4
KESME
BTFSS INTCON,1
RETFIE

INCF SAYAC,F

MOVF SAYAC,W
XORLW D'255'
BTFSC STATUS,Z
CLRF SAYAC
MOVF SAYAC,W
MOVWF PORTD
BCF INTCON,1
RETFIE

ANA
BANKSEL TRISD
CLRF TRISD
BANKSEL PORTD
 CLRF PORTD
BANKSEL INTCON
MOVLW B'10010000'
MOVWF INTCON
BANKSEL SAYAC 
CLRF SAYAC
BANKSEL OPTION_REG
MOVLW H'FF'
MOVWF OPTION_REG
BANKSEL TRISB
MOVLW H'FF'
MOVWF TRISB
BANKSEL PORTB 
CLRF PORTB

DONGU 
GOTO DONGU 
END