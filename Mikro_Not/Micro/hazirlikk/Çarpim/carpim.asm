list p=16F877A 
INCLUDE <P16F877A.INC>
CARPIM1 EQU 0X24
CARPIM2 EQU 0X25
SONUC EQU 0X26
ORG 0X00
GOTO ANAPROGRAM

ANAPROGRAM
	BSF STATUS,RP0
	CLRF TRISB
	BCF STATUS,RP0 

	MOVLW D'5'
	MOVWF CARPIM1

	MOVLW D'2'	
	MOVWF CARPIM2

	MOVLW 0X00 
	MOVWF SONUC	

TOPLA
	MOVF SONUC,W
	ADDWF CARPIM2,0
	MOVWF SONUC

	DECFSZ CARPIM1,1
	GOTO TOPLA
	GOTO SON	
SON
	MOVF SONUC,W
	MOVWF PORTB
	GOTO SON
	END 
	