	list p=16F877A
	INCLUDE <P16F877A.INC>
	SAYAC EQU 0X25
	ORG 0X00
	GOTO ANAPROGRAM
	ORG 0X04
	GOTO KESME
KESME
	BTFSS PIR1,TMR1IF
	RETFIE
	BCF PIR1,TMR1IF
	DECFSZ SAYAC,1
	RETFIE
LED_YAK
	MOVLW 0X01
	XORWF PORTB,1
	MOVLW D'5'	
	MOVWF SAYAC
	RETFIE
ANAPROGRAM
	MOVLW D'5'
	MOVWF SAYAC

	BANKSEL TRISB
	CLRF TRISB

	BANKSEL TMR1H
	MOVLW H'3C'
	MOVLW TMR1H

	BANKSEL TMR1L
	MOVLW H'BA'
	MOVWF TMR1L

	BANKSEL INTCON
	MOVLW B'11000000'	
	MOVWF INTCON

	BANKSEL PIE1
	BSF PIE1,TMR1IE

	BANKSEL T1CON
	MOVLW B'00100001'
	MOVWF T1CON
DONGU
	GOTO DONGU
	END