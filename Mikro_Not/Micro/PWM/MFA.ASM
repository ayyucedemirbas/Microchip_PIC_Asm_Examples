LIST P=16F877A
#INCLUDE <P16F877A.INC>
__CONFIG H'3F31'
ORG 0X000
GOTO ANA_PROG
ORG 0X004
KESME

BÝTÝR
RETFIE

ANA_PROG
 BSF STATUS,RP0
 BCF TRISC,2
 BSF TRISB,0
 BCF OPTION_REG,7
 BSF OPTION_REG,6
 MOVLW B'11010000'
 MOVWF INTCON
 BSF PIE1,1
 MOVLW D'124'
 MOVWF PR2
 BCF STATUS,RP0
 CLRF PORTC
 MOVLW B'00000101'
 MOVWF T2CON ;TMR2 AKTÝF ETME VE PRESCALER 
 MOVLW B'00101100'
 MOVWF CCP1CON
 MOVLW B'01110000'
 MOVWF CCPR1L
 DONGU 
 GOTO DONGU

END