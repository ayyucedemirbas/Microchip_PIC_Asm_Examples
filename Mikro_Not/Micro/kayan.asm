list p=16f877a
#include <p16f877a.inc>
SAYAC EQU 0x24
ORG 0
GOTO ANA 
ORG 4 
GOTO KESME
KESME:
BTFSS INTCON,2
RETFIE
BANKSEL TMR0
MOVLW D'6'
MOVWF TMR0

BANKSEL INTCON
BCF INTCON,2
DECFSZ SAYAC,F
RETFIE
RLF PORTD,F
MOVLW D'255'
MOVWF SAYAC
RETFIE
ANA:
BANKSEL TRISD 
CLRF TRISD
BANKSEL PORTD
CLRF PORTD
MOVLW H'08'
MOVWF PORTD
BANKSEL INTCON
MOVLW B'11100000'
MOVWF INTCON
BANKSEL TMR0
MOVLW D'6'
MOVWF TMR0
BANKSEL OPTION_REG
MOVLW B'00000011'
MOVWF OPTION_REG
BANKSEL SAYAC
MOVLW D'255'
MOVWF SAYAC
DONGU 
GOTO DONGU
END
