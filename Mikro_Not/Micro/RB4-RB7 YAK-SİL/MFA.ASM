LIST P=16F877A
#INCLUDE <P16F877A.INC>
__CONFIG H'3F31'
ORG 0X000
GOTO AAA
ORG 0X004
KESME
BTFSS INTCON,0
GOTO BÝTÝR
BCF INTCON,0
BTFSC PORTB,4
GOTO YAK1
BTFSC PORTB,5
GOTO YAK22
BTFSC PORTB,6
GOTO YAK333
BTFSC PORTB,7
GOTO SÝL
BÝTÝR
BCF INTCON,0
RETFIE
YAK1
BSF PORTD,0
BSF PORTB,0
GOTO BÝTÝR
YAK22
BSF PORTB,1
BSF PORTD,1
GOTO BÝTÝR
YAK333
BSF PORTB,2
BSF PORTD,2
GOTO BÝTÝR
SÝL
CLRF PORTD
BCF PORTB,0
BCF PORTB,1
BCF PORTB,2
GOTO BÝTÝR
AAA
BSF STATUS,RP0
MOVLW B'11110000'
MOVWF TRISB
BSF OPTION_REG,7
MOVLW B'10001000'
MOVWF INTCON
CLRF TRISD
BCF STATUS,RP0
CLRF PORTD
DONGU
	GOTO DONGU
END
